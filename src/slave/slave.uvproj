# Keil uVision project slave.uvproj, settings and files
target slave (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0x0-0x0) IROM(0x0-0x1FFF) CLOCK(24000000)
  output: slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source\include;.\source
  group AiCube
    ./source/: main.c
  group User Sources
    ./source/: app.c ook433.c
